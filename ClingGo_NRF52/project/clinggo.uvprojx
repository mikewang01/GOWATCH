# Keil uVision project clinggo.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=2048 __HEAP_SIZE=1024 S132 NRF_SD_BLE_API_VERSION=5 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 CONFIG_GPIO_AS_PINRESET NRF52_PAN_55 SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS OS_FREERTOS BOARD_CUSTOM NRF_LOG_USES_RTT=1
  c misc: --c99 --gnu
  c include: .\config;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\comp;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\i2s;..\components\drivers_nrf\lpcomp;..\components\drivers_nrf\pdm;..\components\drivers_nrf\power;..\components\drivers_nrf\ppi;..\components\drivers_nrf\pwm;..\components\drivers_nrf\qdec;..\components\drivers_nrf\rng;..\components\drivers_nrf\rtc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\swi;..\components\drivers_nrf\timer;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\twis_slave;..\components\drivers_nrf\uart;..\components\drivers_nrf\usbd;..\components\drivers_nrf\wdt;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hardfault\nrf52;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\pwm;..\components\libraries\queue;..\components\libraries\scheduler;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\timer;..\components\libraries\twi;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\config;..\components\libraries\util;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain;..\external\freertos\config;..\external\freertos\portable\ARM\nrf52;..\external\freertos\portable\CMSIS\nrf52;..\external\freertos\source\include;..\external\segger_rtt;..\config;..\project;.\ClingHal\include;.\ClingSDK\bsp;.\ClingSDK\cling_ble_srv\incs;.\ClingSDK\task;.\tasks;..\external\tiny-AES128;..\components\drivers_nrf\adc;..\components\drivers_nrf\hal;.\iso7816;..\components\nfc\experimental_t4t_lib;.\ClingSDK\ble_pay
  asm define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=2048 __HEAP_SIZE=1024 S132 NRF_SD_BLE_API_VERSION=5 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 CONFIG_GPIO_AS_PINRESET NRF52_PAN_55 SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS ADC_PRESENT
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DS132,-DNRF_SD_BLE_API_VERSION=5,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_55,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DFREERTOS
  asm include: .\config;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\drivers_nrf\clock;..\components\drivers_nrf\common;..\components\drivers_nrf\comp;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\i2s;..\components\drivers_nrf\lpcomp;..\components\drivers_nrf\pdm;..\components\drivers_nrf\power;..\components\drivers_nrf\ppi;..\components\drivers_nrf\pwm;..\components\drivers_nrf\qdec;..\components\drivers_nrf\rng;..\components\drivers_nrf\rtc;..\components\drivers_nrf\saadc;..\components\drivers_nrf\spi_master;..\components\drivers_nrf\spi_slave;..\components\drivers_nrf\swi;..\components\drivers_nrf\timer;..\components\drivers_nrf\twi_master;..\components\drivers_nrf\twis_slave;..\components\drivers_nrf\uart;..\components\drivers_nrf\usbd;..\components\drivers_nrf\wdt;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\fds;..\components\libraries\fstorage;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hardfault\nrf52;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\pwm;..\components\libraries\queue;..\components\libraries\scheduler;..\components\libraries\sensorsim;..\components\libraries\slip;..\components\libraries\timer;..\components\libraries\twi;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\usbd\config;..\components\libraries\util;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain;..\external\freertos\config;..\external\freertos\portable\ARM\nrf52;..\external\freertos\portable\CMSIS\nrf52;..\external\freertos\source\include;..\external\segger_rtt;..\config;.\ble_service
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x20002168 size 0xde98
  group Application
    ./: main.c
  group Board Definition
    ../components/boards/: boards.c
  group Board Support
    ../components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Documentation
    ../../../: license.txt
  group Third Parties
    ../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../external/freertos/source/portable/MemMang/: heap_1.c
    ../external/freertos/portable/ARM/nrf52/: port.c
    ../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../components/ble/ble_services/ble_bas/: ble_bas.c
    ../components/ble/ble_services/ble_dis/: ble_dis.c
    ../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ./: ble_cling.c
  group nRF_Drivers
    ../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../components/drivers_nrf/hal/: nrf_nvmc.c nrf_saadc.c
    ../components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../components/libraries/timer/: app_timer_freertos.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/fds/: fds.c
    ../components/libraries/fstorage/: fstorage.c
    ../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/sensorsim/: sensorsim.c
    ../components/libraries/twi/: app_twi.c
    ../components/nfc/experimental_t4t_lib/: nfc_t4t_lib_keil.lib
    ../components/nfc/experimental_t4t_lib/hal_t4t/: hal_nfc_t4t.c
  group nRF_Log
    ../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c retarget.mod.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Task
    ./tasks/: ble_peripheral_task.c clingtask_input.c clingtask.c clingtask_ouptut.c
    ./: tmp.c
  group Cling_Sdk
    ./ClingSDK/bsp/: Aes.c ancs.c base.c batt.c btle.c butterworth.c cp.c dbg.c font.c fs_fat.c fs_file.c fs_flash.c fs_nflash_rw.c fs_root.c gpio_api.c hal.c homekey.c interrupt.c link.c lis3dh.c nflash_spi.c notific.c oled.c ota.c pedo.c ppg.c reminder.c RTC.c sensor.c sim.c sleep.c sysclk.c sysflash_rw.c system.c system_nrf51.c thermistor.c touch.c tracking.c uart_api.c ui.c uicoData.c uicoTouch.c user.c uv.c uv_calib.c Watchdog.c weather.c wechat_port.c ppg_comm.c FM151.c
  group Cling_Hal
    ./ClingHal/src/: pinmap.c battmgr_hal.c ble_gap_mgr.c flash_hal.c i2cdev_hal.c ota_hal.c rtc_hal.c spidev_hal.c btle_api.c aes_hal.c exti_hal.c
    ./adapters/: sys_power_mgr.c
  group iso7816
    ./iso7816/: iso7816_hal.c iso7816_phy_uart.c
  group Ble_Pay
    ./ClingSDK/ble_pay/: ble_pay_app.c ble_pay_cmd.c ble_pay_mac.c ble_pay_service.c
target flash_s132_nrf52_5.0.0-1.alpha_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_5.0.0-1.alpha_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x20002168 size 0xde98
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
